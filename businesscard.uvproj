# Keil uVision project businesscard.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: LPC1342 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10000FFF) IROM(0-0x3FFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: businesscard
  c flags: Optim=1
  c include: .\Source
  memory RVCT4: ROM 0x0 size 0x4000
  memory RVCT9: RAM 0x10000000 size 0x1000
  group Source Group 1
    ./: startup_LPC13xx.s
    ./Source/: at45db.c bc.c memory.c mscuser.c spi.c system_LPC13xx.c usbdesc.c
